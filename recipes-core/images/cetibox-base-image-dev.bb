require recipes-core/images/cetibox-base-image.inc
require recipes-core/images/cetibox-base-image-dev.inc
require cetibox-base-only.inc

DESCRIPTION = "Image for development work on CETiBOXes"
