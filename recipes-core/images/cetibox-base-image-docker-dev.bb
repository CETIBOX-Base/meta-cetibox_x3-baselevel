require recipes-core/images/cetibox-base-image.inc
require recipes-core/images/cetibox-base-image-docker.inc
require recipes-core/images/cetibox-base-image-dev.inc
require cetibox-base-only.inc

DESCRIPTION = "Image with docker support for development work on CETiBOXes"
